# Keil uVision project dm5680_fw_tx.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C323 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(18000000) MODDP2
  output: dm5680_fw_tx +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: global.c hardware.c i2c.c i2c_device.c isr.c mcu.c monitor.c print.c sfr_ext.c uart.c spi.c dm6300.c rom.c msp_displayport.c camera.c lifetime.c runcam.c
